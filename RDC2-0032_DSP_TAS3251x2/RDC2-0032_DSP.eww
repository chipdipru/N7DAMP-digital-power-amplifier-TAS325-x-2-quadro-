<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RDC2-0032_DSP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


